# Keil uVision project project.uvprojx, settings and files
target STM32F103_Huawei_IoTDA (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103_Huawei_IoTDA +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD
  c misc: --c99
  c include: .\User;.\Hardware;.\System
  asm include: .\System
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f103c8.s
  group System
    ./System/: system_stm32f103.c stm32f103x8.h
  group User
    ./User/: main.c app_config.h
  group Hardware
    ./Hardware/: util.c util.h delay.c delay.h uart.c uart.h debug.c debug.h dht11.c dht11.h light_sensor.c light_sensor.h sha256.c sha256.h esp8266.c esp8266.h huawei_iotda.c huawei_iotda.h jwsensor.c jwsensor.h
